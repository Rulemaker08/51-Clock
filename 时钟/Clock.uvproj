# Keil uVision project Clock.uvproj, settings and files
target Clock (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\System;.\Hardware
  group System
    ./System/: Timer.c Timer.h
  group Hardware
    ./Hardware/: AT24C02.c AT24C02.h DS1302.c DS1302.h I2C.c I2C.h key.c key.h Matrix.c Matrix.h MatrixKey.c MatrixKey.h Nixie.c Nixie.h
  group User
    ./User/: main.c Switch.h Getkey.c Alarm.c Stopwatch.c Watch.c
  group Readme
    ./: Readme.txt
